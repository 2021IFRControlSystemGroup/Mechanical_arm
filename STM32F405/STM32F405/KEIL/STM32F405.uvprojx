# Keil uVision project STM32F405.uvprojx, settings and files
target STM32F405 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F405 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F405;..\STM32F405\CORE;..\STM32F405\FWLIB;..\STM32F405\FWLIB\inc;..\STM32F405\FWLIB\src;..\ROBOT\ALGO;..\ROBOT\ANALYSIS;..\ROBOT\APP;..\ROBOT\BSP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c
  group STM32F405
    ../STM32F405/FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../STM32F405/: stm32f4xx_it.c system_stm32f4xx.c sys.c
    ../STM32F405/CORE/: startup_stm32f40_41xxx.s
  group BSP
    ../ROBOT/BSP/: bsp.c dma2.c time2.c beep.c
  group APP
    ../../STM32F405/ROBOT/APP/: led.c
    ../ROBOT/APP/: can1.c arm.c chassis.c can2.c
  group ANALYSIS
    ../ROBOT/ANALYSIS/: remote_analysis.c can1_analysis.c
  group ALGO
    ../ROBOT/ALGO/: delay.c
